# Keil uVision project Ultrasonic.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ultrasonic
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Ultrasonic
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./: main.c APP_program.c
  group MCAL
    ./: SYSCNTRL_program.c TIMER1_program.c TIMER0_program.c GPIO_program.c
  group HAL
    ./: HC05_program.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
