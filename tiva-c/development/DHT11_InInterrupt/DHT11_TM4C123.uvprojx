# Keil uVision project DHT11_TM4C123.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DHT11_TM4C123
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\DHT11_TM4C123
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c GPIO_program.c NVIC_program.c SYSCNTRL_program.c SysTick_program.c DHT11_program.c TIMER0_program.c UART_program.c APP_program.c SCB_program.c
    ../LCD_4Bit_TM4C123/: LCD_program.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.1
