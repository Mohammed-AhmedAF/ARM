	AREA |.text|,CODE,READONLY,ALIGN=2
	THUMB
	EXPORT main
		
SYSCTL_RCGCGPIO_R EQU 0x400FE608
GPIO_PORTF_DIR_R EQU 0x40025400
GPIO_PORTF_DEN_R EQU 0x4002551C
GPIO_PORTF_DATA_R EQU 0x400253FC

LED_RED EQU 0x02
LED_BLUE EQU 0x04
LED_GREEN EQU 0x08

main
	BL LED_INIT
	B loop

loop 
	BL LED_ON
	B loop

LED_INIT
	LDR R1,=SYSCTL_RCGCGPIO_R
	MOV R0,#0x20
	STR R0,[R1]
	
	LDR R1,=GPIO_PORTF_DIR_R
	MOV R0,LED_GREEN
	STR R0,[R1]
	
	LDR R1,=GPIO_PORTF_DEN_R
	MOV R0,LED_GREEN
	STR R0,[R1]
	BX LR
	

LED_ON
	LDR R1,=GPIO_PORTF_DATA_R
	MOV R0,LED_GREEN
	STR R0,[R1]
	
ALIGN
END
	